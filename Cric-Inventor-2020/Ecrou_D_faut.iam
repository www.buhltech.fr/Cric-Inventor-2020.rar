# Autodesk Inventor assembly: Ecrou_D_faut
## iProperties
Created: 2011-10
Part Number: Ecrou_D_faut
Document SubType Name: Assembly
Designer: Bruno
Author: Bruno
