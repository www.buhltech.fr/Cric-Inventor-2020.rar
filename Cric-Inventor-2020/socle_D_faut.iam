# Autodesk Inventor assembly: socle_D_faut
## iProperties
Created: 2011-10
Part Number: socle_D_faut
Document SubType Name: Assembly
Designer: Bruno
Author: Bruno
