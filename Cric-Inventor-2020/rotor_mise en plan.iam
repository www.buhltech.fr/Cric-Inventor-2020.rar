# Autodesk Inventor assembly: rotor_mise en plan
## iProperties
Created: 2011-10
Part Number: rotor_mise en plan
Document SubType Name: Assembly
Designer: Bruno
Author: Bruno
