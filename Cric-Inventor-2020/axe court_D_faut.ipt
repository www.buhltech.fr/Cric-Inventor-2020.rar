# Autodesk Inventor part: axe court_D_faut
## iProperties
Created: 2011-10
Part Number: axe court_D_faut
Document SubType Name: Modeling
Designer: Bruno
Author: Bruno
## Feature names
1. Base1
