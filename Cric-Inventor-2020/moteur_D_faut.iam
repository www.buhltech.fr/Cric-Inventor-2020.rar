# Autodesk Inventor assembly: moteur_D_faut
## iProperties
Created: 2011-10
Part Number: moteur_D_faut
Document SubType Name: Assembly
Designer: Bruno
Author: Bruno
