# Autodesk Inventor assembly: Roulement_r1rb11_D_faut
## iProperties
Created: 2011-10
Part Number: Roulement_r1rb11_D_faut
Document SubType Name: Assembly
Designer: Bruno
Author: Bruno
